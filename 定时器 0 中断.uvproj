# Keil uVision project 定时器 0 中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 定时器 0 中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c system.c SystemManage.c SystemState_Idle.c SystemState_Normal.c SystemState_Ready.c timer.c SystemManageDef.c usart.c crc.c register.c timer_usingTimer0.c LCD1602.c LCD12864.c
